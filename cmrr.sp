CMRR circuit
; For the purpose of plotting CMRR, I have replicated
; the same differential amplifier twice
; one in Differential input and one in common
; This is just to obtain CMRR bode plot
; In reality I have only a single amplifier
M1 N028 in1 N034 N034 CMOSN l=0.8u w=399.0422985u
M3 N016 N024 N020 N020 CMOSN l=0.8u w=3.832402235u
M4 N016 N014 N010 N010 CMOSP l=0.8u w=0.08726248081u
M5 N010 N008 N004 N004 CMOSP l=0.8u w=0.08726248081u
M8 N008 N008 N002 N002 CMOSP l=0.8u w=87.26248481u
M9 N014 N014 N008 N008 CMOSP l=0.8u w=87.26248481u
M10 N024 N024 N026 N026 CMOSN l=0.8u w=3832.402235u
I1 N014 N024 50µ
V1 in1 in2 SINE(0 10m 1k) AC 10m
V2 in2 0 124.7m
V3 N001 0 3.5
M2 N020 N026 N028 N028 CMOSN l=0.8u w=3.832402235u
M11 N026 N026 N032 N032 CMOSN l=0.8u w=977.5538809u
M7 N002 N002 N001 N001 CMOSP l=0.8u w=319.4316672u
M6 N004 N002 N001 N001 CMOSP l=0.8u w=0.3194316672u
M12 N029 in2 N034 N034 CMOSN l=0.8u w=399.0422985u
M13 N017 N024 N021 N021 CMOSN l=0.8u w=3.832402235u
M14 N017 N014 N011 N011 CMOSP l=0.8u w=0.08726248481u
M15 N011 N008 N005 N005 CMOSP l=0.8u w=0.08726248481u
M16 N021 N026 N029 N029 CMOSN l=0.8u w=3.832402235u
M17 N005 N002 N001 N001 CMOSP l=0.8u w=0.3194316672u
M18 N034 N032 N038 N038 CMOSN l=0.8u w=3.547042653u
M19 N038 N037 0 0 CMOSN l=0.8u w=3.547042653u
M20 N032 N032 N037 N037 CMOSN l=0.8u w=1773.521327u
M21 N037 N037 0 0 CMOSN l=0.8u w=1773.521327u
M22 N030 in3 N035 N035 CMOSN l=0.8u w=399.0422985u
M23 N018 N025 N022 N022 CMOSN l=0.8u w=3.832402235u
M24 N018 N015 N012 N012 CMOSP l=0.8u w=0.08726248081u
M25 N012 N009 N006 N006 CMOSP l=0.8u w=0.08726248081u
M26 N009 N009 N003 N003 CMOSP l=0.8u w=87.26248481u
M27 N015 N015 N009 N009 CMOSP l=0.8u w=87.26248481u
M28 N025 N025 N027 N027 CMOSN l=0.8u w=3832.402235u
I2 N015 N025 50µ
V4 in3 N036 SINE(0 10m 1k) AC 10m
V5 N036 0 124.7m
M29 N022 N027 N030 N030 CMOSN l=0.8u w=3.832402235u
M30 N027 N027 N033 N033 CMOSN l=0.8u w=977.5538809u
M31 N003 N003 N001 N001 CMOSP l=0.8u w=319.4316672u
M32 N006 N003 N001 N001 CMOSP l=0.8u w=0.3194316672u
M33 N031 in3 N035 N035 CMOSN l=0.8u w=399.0422985u
M34 N019 N025 N023 N023 CMOSN l=0.8u w=3.832402235u
M35 N019 N015 N013 N013 CMOSP l=0.8u w=0.08726248481u
M36 N013 N009 N007 N007 CMOSP l=0.8u w=0.08726248481u
M37 N023 N027 N031 N031 CMOSN l=0.8u w=3.832402235u
M38 N007 N003 N001 N001 CMOSP l=0.8u w=0.3194316672u
M39 N035 N033 N040 N040 CMOSN l=0.8u w=3.547042653u
M40 N040 N039 0 0 CMOSN l=0.8u w=3.547042653u
M41 N033 N033 N039 N039 CMOSN l=0.8u w=1773.521327u
M42 N039 N039 0 0 CMOSN l=0.8u w=1773.521327u
C1 N016 out1 1p
C2 N017 out2 1p
C3 N018 out3 1p
C4 N019 out4 1p

.lib mosis_350.lib

.ac dec 10 1 1G

.end
